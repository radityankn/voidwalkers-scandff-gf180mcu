v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {d_flip_flop.sym} 70 -40 0 0 {name=x1}
