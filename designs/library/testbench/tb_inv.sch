v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {../ring_osc/inv.sym} 80 -40 0 0 {name=x1}
